# Keil uVision project usart_dma_double_buffer_transfer.uvprojx, settings and files
target usart_dma_double_buffer_transfer debug (6130001::V6.13.1::.\ARMCLANG)
  device: LPC55S16JBD100 NXP
  pack: NXP.LPC55S16_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: usart_dma_double_buffer_transfer.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_LPC55S16JBD100, MCUXPRESSO_SDK
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../../../../../devices/LPC55S16/utilities/debug_console_lite;../../../../../../devices/LPC55S16/drivers;../../../../../../devices/LPC55S16;../../../../../../components/uart;../../../../../../components/lists;../../../../../../CMSIS/Core/Include
  asm define: CPU_LPC55S69JBD100_cm33_core0, DEBUG,__CC_ARM,KEIL, DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0x20040000 size 0x4000
  memory RVCT7: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC55S16_flash.scf
  link misc: ../../../../../../devices/LPC55S16/arm/keil_lib_power.lib --remove --entry=Reset_Handler
  group source
    ../: usart_dma_double_buffer_transfer.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group utilities
    ../../../../../../devices/LPC55S16/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group drivers
    ../../../../../../devices/LPC55S16/drivers/: fsl_usart_dma.h fsl_usart_dma.c fsl_usart.h fsl_usart.c fsl_dma.c fsl_dma.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_iocon.h fsl_gpio.h fsl_gpio.c fsl_inputmux.h fsl_inputmux.c fsl_clock.h fsl_clock.c fsl_flexcomm.h fsl_flexcomm.c fsl_reset.h fsl_reset.c fsl_inputmux_connections.h
  group LPC55S16/drivers
    ../../../../../../devices/LPC55S16/drivers/: fsl_power.h fsl_power.c
  group device
    ../../../../../../devices/LPC55S16/: fsl_device_registers.h LPC55S16.h LPC55S16_features.h system_LPC55S16.c system_LPC55S16.h
  group startup
    ../../../../../../devices/LPC55S16/arm/: startup_LPC55S16.S
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
target usart_dma_double_buffer_transfer release (6130001::V6.13.1::.\ARMCLANG)
  device: LPC55S16JBD100 NXP
  pack: NXP.LPC55S16_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: usart_dma_double_buffer_transfer.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_LPC55S16JBD100, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: CPU_LPC55S69JBD100_cm33_core0, NDEBUG,__CC_ARM,KEIL, NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0x20040000 size 0x4000
  memory RVCT7: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC55S16_flash.scf
  link misc: as above
