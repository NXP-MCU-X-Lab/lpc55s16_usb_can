# Keil uVision project dev_cdc_vcom_bm.uvprojx, settings and files
target dev_cdc_vcom_bm debug (6130001::V6.13.1::.\ARMCLANG)
  device: LPC55S16JBD100 NXP
  pack: NXP.LPC55S16_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: dev_cdc_vcom_bm.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: _DEBUG=1, DEBUG, CPU_LPC55S16JBD100=1, USB_STACK_BM, USB_STACK_USE_DEDICATED_RAM=1, FSL_OSA_BM_TASK_ENABLE=0, FSL_OSA_BM_TIMER_CONFIG=0, SDK_DEBUGCONSOLE=1, MCUXPRESSO_SDK
  c misc: -mno-unaligned-access  -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../../../../../middleware/usb/device;../../../../../../middleware/usb/include;../../../../../../devices/LPC55S16/utilities/debug_console_lite;../../../../../../devices/LPC55S16/drivers;../../../../../../devices/LPC55S16;../../../../../../middleware/usb/phy;../../../../../../components/uart;../../../../../../components/lists;../../../../../../components/osa;../../../../../../CMSIS/Core/Include
  asm define: CPU_LPC55S69JBD100_cm33_core0, DEBUG,__CC_ARM,KEIL, DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0x20040000 size 0x4000
  memory RVCT7: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC55S16_flash.scf
  link misc: ../../../../../../devices/LPC55S16/arm/keil_lib_power.lib --remove --entry=Reset_Handler --predefine="-D__stack_size__=0x2000" --predefine="-D__heap_size__=0x1000" --predefine="-D__usb_use_usbram__=1"
  group doc
    ../: readme.txt
  group source
    ../: usb_device_descriptor.c usb_device_descriptor.h virtual_com.c virtual_com.h usb_device_config.h
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group usb/device/source/lpcip3511
    ../../../../../../middleware/usb/device/: usb_device_lpcip3511.c usb_device_lpcip3511.h
  group utilities
    ../../../../../../devices/LPC55S16/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group usb/device/source
    ../: usb_device_ch9.c usb_device_ch9.h
    ../../../../../../middleware/usb/device/: usb_device_dci.c usb_device_dci.h usb_device_dci.h
  group usb/device/class
    ../: usb_device_class.c usb_device_class.h
  group usb/device/class/cdc
    ../: usb_device_cdc_acm.c usb_device_cdc_acm.h
  group drivers
    ../../../../../../devices/LPC55S16/drivers/: fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_usart.h fsl_usart.c fsl_flexcomm.h fsl_flexcomm.c fsl_gpio.h fsl_gpio.c fsl_iocon.h fsl_reset.h fsl_reset.c
  group LPC55S16/drivers
    ../../../../../../devices/LPC55S16/drivers/: fsl_power.h fsl_power.c
  group device
    ../../../../../../devices/LPC55S16/: fsl_device_registers.h LPC55S16.h LPC55S16_features.h system_LPC55S16.c system_LPC55S16.h
  group startup
    ../../../../../../devices/LPC55S16/arm/: startup_LPC55S16.S
  group usb/phy
    ../../../../../../middleware/usb/phy/: usb_phy.c usb_phy.h
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group usb/device/include
    ../../../../../../middleware/usb/device/: usb_device.h usb_device.h
  group component/osa
    ../../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_config.h fsl_os_abstraction_bm.h fsl_os_abstraction_bm.c
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
  group usb/include
    ../../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h
target dev_cdc_vcom_bm release (6130001::V6.13.1::.\ARMCLANG)
  device: LPC55S16JBD100 NXP
  pack: NXP.LPC55S16_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: dev_cdc_vcom_bm.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: _DEBUG=0, NDEBUG, CPU_LPC55S16JBD100=1, USB_STACK_BM, USB_STACK_USE_DEDICATED_RAM=1, FSL_OSA_BM_TASK_ENABLE=0, FSL_OSA_BM_TIMER_CONFIG=0, SDK_DEBUGCONSOLE=1, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: CPU_LPC55S69JBD100_cm33_core0, NDEBUG,__CC_ARM,KEIL, NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0x20040000 size 0x4000
  memory RVCT7: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC55S16_flash.scf
  link misc: as above
